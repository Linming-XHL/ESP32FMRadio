## sdkconfig.defaults
```kconfig
# Enable custom partition table
CONFIG_PARTITION_TABLE_CUSTOM=y
CONFIG_PARTITION_TABLE_SINGLE_APP=n
CONFIG_PARTITION_TABLE_FILENAME="partitions.csv"
```
